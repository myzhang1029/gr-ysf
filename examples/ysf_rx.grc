options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ysf_rx
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 4.8e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 432.0e6
  states: {}
- name: channel_bandwidth
  id: variable
  parameters:
    value: 2*(baud_rate+deviation)
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate/decimator
  states: {}
- name: decimator
  id: variable
  parameters:
    value: '25'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 2.7e3
  states: {}
- name: fsm
  id: variable
  parameters:
    value: trellis.fsm(1,2,[0b10011, 0b11101])
  states: {}
- name: interleaver_20_5
  id: variable
  parameters:
    value: trellis.interleaver(100, (0, 5, 10, 15, 20, 25, 30, 35, 40, 45, 50, 55, 60, 65, 70, 75, 80, 85, 90, 95, 1, 6, 11, 16, 21, 26, 31, 36, 41, 46, 51, 56, 61, 66, 71, 76, 81, 86, 91, 96, 2, 7, 12, 17, 22, 27, 32, 37, 42, 47, 52, 57, 62, 67, 72, 77, 82, 87, 92, 97, 3, 8, 13, 18, 23, 28, 33, 38, 43, 48, 53, 58, 63, 68, 73, 78, 83, 88, 93, 98, 4, 9, 14, 19, 24, 29, 34, 39, 44, 49, 54, 59, 64, 69, 74, 79, 84, 89, 94, 99))
  states: {}
- name: interleaver_20_9
  id: variable
  parameters:
    value: trellis.interleaver(180, (0, 9, 18, 27, 36, 45, 54, 63, 72, 81, 90, 99, 108, 117, 126, 135, 144, 153, 162, 171, 1, 10, 19, 28, 37, 46, 55, 64, 73, 82, 91, 100, 109, 118, 127, 136, 145, 154, 163, 172, 2, 11, 20, 29, 38, 47, 56, 65, 74, 83, 92, 101, 110, 119, 128, 137, 146, 155, 164, 173, 3, 12, 21, 30, 39, 48, 57, 66, 75, 84, 93, 102, 111, 120, 129, 138, 147, 156, 165, 174, 4, 13, 22, 31, 40, 49, 58, 67, 76, 85, 94, 103, 112, 121, 130, 139, 148, 157, 166, 175, 5, 14, 23, 32, 41, 50, 59, 68, 77, 86, 95, 104, 113, 122, 131, 140, 149, 158, 167, 176, 6, 15, 24, 33, 42, 51, 60, 69, 78, 87, 96, 105, 114, 123, 132, 141, 150, 159, 168, 177, 7, 16, 25, 34, 43, 52, 61, 70, 79, 88, 97, 106, 115, 124, 133, 142, 151, 160, 169, 178, 8, 17, 26, 35, 44, 53, 62, 71, 80, 89, 98, 107, 116, 125, 134, 143, 152, 161, 170, 179))
  states: {}
- name: interleaver_4_26
  id: variable
  parameters:
    value: trellis.interleaver(104, (0,26,52,78,1,27,53,79,2,28,54,80,3,29,55,81,4,30,56,82,5,31,57,83,6,32,58,84,7,33,59,85,8,34,60,86,9,35,61,87,10,36,62,88,11,37,63,89,12,38,64,90,13,39,65,91,14,40,66,92,15,41,67,93,16,42,68,94,17,43,69,95,18,44,70,96,19,45,71,97,20,46,72,98,21,47,73,99,22,48,74,100,23,49,75,101,24,50,76,102,25,51,77,103))
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.1415926'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 432.5e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '20'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '20'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 3.0*channel_rate/(2*pi*deviation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '8000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '8000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: symbols.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: demod.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: filtered_demod.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: fich_deinterleaved.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: capture.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: hb9frv.cfile
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '12'
    n: '24'
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: '96'
    n: '100'
    offset: '0'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1)
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: recording.wav
    format: FORMAT_WAV
    samp_rate: '8000'
  states: {state: disabled}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_0_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_0_0_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[3,2,0,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: '0.001'
    max_dev: '1e-5'
    osps: '1'
    sps: channel_rate/baud_rate
    taps: firdes.root_raised_cosine(nfilts, nfilts*channel_rate, baud_rate, 0.2, int(11*channel_rate/baud_rate*nfilts))
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: target_freq-center_freq
    decim: decimator
    samp_rate: samp_rate
    taps: filter.firdes.low_pass(1.0, samp_rate, 1.2*channel_bandwidth/2, 0.2*channel_bandwidth/2, window.WIN_HANN)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: channel_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:0,0,1,1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0:1,0,1,1
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1:1,0,1,1
    label1: ''
    label2: ''
    size: '1024'
    srate: channel_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2:0,0,1,1
    label1: RRC-Filtered Demod
    label2: Raw Demod
    nconnections: '2'
    size: '2048'
    srate: channel_rate
    tr_chan: '1'
    tr_delay: '0.015'
    tr_level: '6'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.25'
    alpha2: '0.25'
    grid: 'True'
    gui_hint: tabs@3:0,0,1,1
    label1: ''
    label2: ''
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '2048'
    srate: baud_rate
    tr_level: '0.25'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.2'
    decim: '1'
    gain: '1'
    ntaps: '45'
    samp_rate: channel_rate
    sym_rate: baud_rate
    type: fir_filter_fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Wideband
    label1: Channel
    label2: Demod
    label3: Symbols
    num_tabs: '4'
  states: {}
- name: trellis_metrics_x_0
  id: trellis_metrics_x
  parameters:
    card: fsm.O()
    dim: '1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: '[0.,1.,2.,3.]'
    type: f
  states: {}
- name: trellis_metrics_x_0_0
  id: trellis_metrics_x
  parameters:
    card: fsm.O()
    dim: '1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: '[0.,1.,2.,3.]'
    type: f
  states: {}
- name: trellis_metrics_x_0_0_0
  id: trellis_metrics_x
  parameters:
    card: fsm.O()
    dim: '1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: '[0.,1.,2.,3.]'
    type: f
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver_20_5.K()
    syms_per_block: '1'
    table: interleaver_20_5.DEINTER()
    type: byte
  states: {}
- name: trellis_permutation_0_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver_20_9.K()
    syms_per_block: '1'
    table: interleaver_20_9.DEINTER()
    type: byte
  states: {}
- name: trellis_permutation_0_0_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver_20_5.K()
    syms_per_block: '1'
    table: interleaver_20_5.DEINTER()
    type: byte
  states: {}
- name: trellis_permutation_0_0_0_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver_4_26.K()
    syms_per_block: '1'
    table: interleaver_4_26.DEINTER()
    type: byte
  states: {}
- name: trellis_viterbi_x_0
  id: trellis_viterbi_x
  parameters:
    block_size: '100'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    type: b
  states: {}
- name: trellis_viterbi_x_0_0
  id: trellis_viterbi_x
  parameters:
    block_size: '180'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    type: b
  states: {}
- name: trellis_viterbi_x_0_0_0
  id: trellis_viterbi_x
  parameters:
    block_size: '100'
    final_state: '-1'
    fsm_args: fsm
    init_state: '0'
    type: b
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: ysf_dch_sink_b_0
  id: ysf_dch_sink_b
  parameters: {}
  states: {}
- name: ysf_dch_sink_b_0_0
  id: ysf_dch_sink_b
  parameters: {}
  states: {}
- name: ysf_deframer_bb_0
  id: ysf_deframer_bb
  parameters:
    threshold: '1'
  states: {}
- name: ysf_fich_sink_b_0
  id: ysf_fich_sink_b
  parameters: {}
  states: {}
- name: ysf_fr_vch_decoder_bb_0
  id: ysf_fr_vch_decoder_bb
  parameters: {}
  states: {}
- name: ysf_mbelib_block_bf_0
  id: ysf_mbelib_block_bf
  parameters:
    codec: AMBE 2450
  states: {}
- name: ysf_mbelib_block_bf_0_0
  id: ysf_mbelib_block_bf
  parameters:
    codec: IMBE 4400
  states: {}
- name: ysf_pager_slicer_fb_0
  id: ysf_pager_slicer_fb
  parameters:
    alpha: '0'
  states: {}
- name: ysf_vd2_vch_decoder_bb_0
  id: ysf_vd2_vch_decoder_bb
  parameters: {}
  states: {}

connections:
- [analog_agc_xx_0, '0', audio_sink_0, '0']
- [analog_agc_xx_0, '0', blocks_wavfile_sink_0, '0']
- [analog_agc_xx_0_0, '0', audio_sink_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_file_sink_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [analog_quadrature_demod_cf_0_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_char_to_float_1, '0', trellis_metrics_x_0, '0']
- [blocks_char_to_float_1_0, '0', trellis_metrics_x_0_0, '0']
- [blocks_char_to_float_1_1, '0', trellis_metrics_x_0_0_0, '0']
- [blocks_file_source_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_file_source_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_file_sink_2, '0']
- [blocks_keep_m_in_n_0, '0', ysf_fich_sink_b_0, '0']
- [blocks_keep_m_in_n_1, '0', blocks_keep_m_in_n_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', trellis_permutation_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', ysf_fr_vch_decoder_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_xor_xx_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_xor_xx_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_xor_xx_0_0_0, '0']
- [blocks_xor_xx_0, '0', ysf_dch_sink_b_0, '0']
- [blocks_xor_xx_0_0, '0', ysf_dch_sink_b_0_0, '0']
- [blocks_xor_xx_0_0_0, '0', ysf_vd2_vch_decoder_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0, '0', ysf_deframer_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_file_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_3, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [trellis_metrics_x_0, '0', trellis_viterbi_x_0, '0']
- [trellis_metrics_x_0_0, '0', trellis_viterbi_x_0_0, '0']
- [trellis_metrics_x_0_0_0, '0', trellis_viterbi_x_0_0_0, '0']
- [trellis_permutation_0, '0', blocks_char_to_float_1, '0']
- [trellis_permutation_0_0, '0', blocks_char_to_float_1_0, '0']
- [trellis_permutation_0_0_0, '0', blocks_char_to_float_1_1, '0']
- [trellis_permutation_0_0_0_0, '0', blocks_xor_xx_0_0_0, '1']
- [trellis_viterbi_x_0, '0', blocks_keep_m_in_n_1, '0']
- [trellis_viterbi_x_0_0, '0', blocks_xor_xx_0, '1']
- [trellis_viterbi_x_0_0_0, '0', blocks_xor_xx_0_0, '1']
- [virtual_source_0, '0', ysf_pager_slicer_fb_0, '0']
- [ysf_deframer_bb_0, '0', trellis_permutation_0, '0']
- [ysf_deframer_bb_0, '1', trellis_permutation_0_0, '0']
- [ysf_deframer_bb_0, '2', trellis_permutation_0_0_0, '0']
- [ysf_deframer_bb_0, '3', blocks_unpack_k_bits_bb_0, '0']
- [ysf_deframer_bb_0, '4', blocks_unpack_k_bits_bb_0_0, '0']
- [ysf_fich_sink_b_0, demux_instruction, ysf_deframer_bb_0, demux_instruction]
- [ysf_fr_vch_decoder_bb_0, '0', ysf_mbelib_block_bf_0_0, '0']
- [ysf_mbelib_block_bf_0, '0', analog_agc_xx_0, '0']
- [ysf_mbelib_block_bf_0_0, '0', analog_agc_xx_0_0, '0']
- [ysf_pager_slicer_fb_0, '0', digital_map_bb_0_0, '0']
- [ysf_vd2_vch_decoder_bb_0, '0', ysf_mbelib_block_bf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
